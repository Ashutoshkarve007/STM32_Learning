<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Timer 02.ewp</path>
  </project>
  <batchBuild />
</workspace>
